## config/west.yml
```yaml
manifest:
  projects:
    - name: zmk
      url: https://github.com
      revision: v0.3
      import: app/west.yml
  self:
    path: config
```
